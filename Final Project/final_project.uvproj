# Keil uVision project final_project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: final_project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c inttypes.h lcd.h lcd.c
